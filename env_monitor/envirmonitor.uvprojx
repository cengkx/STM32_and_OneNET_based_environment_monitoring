# Keil uVision project envirmonitor.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: envirmonitor +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,
  c include: .\CMSIS;.\FWLib\inc;.\User;.\System\delay;.\System\sys;.\System\usart;.\HARDWARE\OLED;.\HARDWARE\DHT11;.\HARDWARE\MQ-2;.\HARDWARE\GY302;.\HARDWARE\BT;.\NET\onenet\inc;.\NET\device\inc;.\NET\MQTT;.\HARDWARE\BEEP;.\HARDWARE\LED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ./CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
    ./User/: stm32f10x_it.c
  group FWLIB
    ./FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./User/: main.c
  group SYSTEM
    ./System/delay/: delay.c
    ./System/sys/: sys.c
    ./System/usart/: usart.c
  group HARDWARE
    ./HARDWARE/OLED/: oled.c
    ./HARDWARE/DHT11/: dht11.c
    ./HARDWARE/MQ-2/: MQ-2.c
    ./HARDWARE/GY302/: GY302.c
    ./HARDWARE/BT/: bt.c
    ./HARDWARE/BEEP/: beep.c
    ./HARDWARE/LED/: led.c
  group OneNET
    ./NET/onenet/src/: onenet.c
  group net_protocol
    ./NET/MQTT/: MqttKit.c
  group net_device
    ./NET/device/src/: esp8266.c
  group shuoming
    ./: shuoming.txt
